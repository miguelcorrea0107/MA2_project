v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {inv_sky130_a.sym} 60 -60 0 0 {name=x1}
C {devices/vsource.sym} -90 0 0 0 {name=V1 value=3 savecurrent=false}
