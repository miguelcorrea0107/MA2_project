v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_tests/test_analog.sym} -20 -20 0 0 {name=x1}
