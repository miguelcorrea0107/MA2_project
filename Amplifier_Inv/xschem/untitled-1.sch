v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_tests/test_ac.sym} 10 -20 0 0 {name=x1}
